Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2021-12-28T13:26:22
Author: Vaarna, Verna
Organization: WSP
Made in: ASIFC - 2.11.0.854

# IfcSite, Site
RefElevation: 0 mm

# IfcProxy (249)
ProxyType: PRODUCT
